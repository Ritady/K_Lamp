# IAR project triac_light.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: code\STM8S_StdPeriph_Driver\inc; code\driver; code
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: triac_light.hex
  ILINK.IlinkOutputFile: triac_light.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group code
    code/: main.c main.h protocol.c protocol.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group code/Driver
    code/driver/: driver_triac.c driver_triac.h pwm_comm.c pwm_comm.h
  group code/STM8S_StdPeriph_Driver
    code/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
